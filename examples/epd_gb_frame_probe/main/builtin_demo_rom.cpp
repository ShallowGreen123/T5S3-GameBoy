#include "builtin_demo_rom.h"

#include <string.h>

namespace {

constexpr size_t kDemoRomSize = 32U * 1024U;
constexpr uint16_t kHeaderChecksumStart = 0x0134U;
constexpr uint16_t kHeaderChecksumEnd = 0x014CU;
constexpr uint16_t kGlobalChecksumHigh = 0x014EU;
constexpr uint16_t kGlobalChecksumLow = 0x014FU;
constexpr uint8_t kNintendoLogo[48] = {
    0xCE, 0xED, 0x66, 0x66, 0xCC, 0x0D, 0x00, 0x0B,
    0x03, 0x73, 0x00, 0x83, 0x00, 0x0C, 0x00, 0x0D,
    0x00, 0x08, 0x11, 0x1F, 0x88, 0x89, 0x00, 0x0E,
    0xDC, 0xCC, 0x6E, 0xE6, 0xDD, 0xDD, 0xD9, 0x99,
    0xBB, 0xBB, 0x67, 0x63, 0x6E, 0x0E, 0xEC, 0xCC,
    0xDD, 0xDC, 0x99, 0x9F, 0xBB, 0xB9, 0x33, 0x3E,
};
constexpr uint8_t kProgram[] = {
    0xF3,
    0x31, 0xFE, 0xFF,
    0xF0, 0x44, 0xFE, 0x90, 0x38, 0xFA,
    0xAF, 0xE0, 0x40, 0xE0, 0x42, 0xE0, 0x43, 0xE0, 0x4A, 0xE0, 0x4B,
    0x3E, 0x1B, 0xE0, 0x47,
    0x21, 0x10, 0x80, 0x06, 0x04,
    0x3E, 0xAA, 0x22, 0x22, 0x3E, 0x55, 0x22, 0x22, 0x05, 0x20, 0xF5,
    0x21, 0x00, 0x98, 0x01, 0x00, 0x04,
    0x36, 0x01, 0x23, 0x0B, 0x78, 0xB1, 0x20, 0xF8,
    0x3E, 0x91, 0xE0, 0x40,
    0xF0, 0x44, 0xFE, 0x90, 0x38, 0xFA, 0xF0, 0x43, 0x3C, 0xE0, 0x43,
    0xF0, 0x44, 0xFE, 0x90, 0x30, 0xFA, 0x18, 0xED,
};

uint8_t g_demo_rom[kDemoRomSize];
bool g_demo_rom_ready = false;

void build_demo_rom() {
  if (g_demo_rom_ready) {
    return;
  }

  memset(g_demo_rom, 0x00, sizeof(g_demo_rom));

  g_demo_rom[0x0100] = 0xC3;
  g_demo_rom[0x0101] = 0x50;
  g_demo_rom[0x0102] = 0x01;

  memcpy(&g_demo_rom[0x0104], kNintendoLogo, sizeof(kNintendoLogo));
  memcpy(&g_demo_rom[0x0134], "EPD DEMO", 8);

  g_demo_rom[0x0143] = 0x00;
  g_demo_rom[0x0144] = 0x00;
  g_demo_rom[0x0145] = 0x00;
  g_demo_rom[0x0146] = 0x00;
  g_demo_rom[0x0147] = 0x00;
  g_demo_rom[0x0148] = 0x00;
  g_demo_rom[0x0149] = 0x00;
  g_demo_rom[0x014A] = 0x01;
  g_demo_rom[0x014B] = 0x00;
  g_demo_rom[0x014C] = 0x00;

  memcpy(&g_demo_rom[0x0150], kProgram, sizeof(kProgram));

  uint8_t header_checksum = 0;
  for (uint16_t i = kHeaderChecksumStart; i <= kHeaderChecksumEnd; ++i) {
    header_checksum = static_cast<uint8_t>(header_checksum - g_demo_rom[i] - 1U);
  }
  g_demo_rom[0x014D] = header_checksum;

  uint16_t global_checksum = 0;
  for (uint16_t i = 0; i < kDemoRomSize; ++i) {
    if (i == kGlobalChecksumHigh || i == kGlobalChecksumLow) {
      continue;
    }
    global_checksum = static_cast<uint16_t>(global_checksum + g_demo_rom[i]);
  }
  g_demo_rom[kGlobalChecksumHigh] = static_cast<uint8_t>(global_checksum >> 8);
  g_demo_rom[kGlobalChecksumLow] = static_cast<uint8_t>(global_checksum & 0xFFU);

  g_demo_rom_ready = true;
}

}  // namespace

const uint8_t *builtin_demo_rom_data() {
  build_demo_rom();
  return g_demo_rom;
}

size_t builtin_demo_rom_size() {
  return kDemoRomSize;
}

const char *builtin_demo_rom_name() {
  return "Bundled homebrew demo";
}
